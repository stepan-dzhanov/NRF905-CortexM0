<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CortexM0+NrF905.ewp</path>
  </project>
  <batchBuild />
</workspace>
